# Keil uVision project Discovery_F4_MP3.uvprojx, settings and files
target STM32F4-Discovery (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Disco_F4_MP3
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT=1U,__CORTEX_M4F, __CMSIS_RTOS,DEBUG_BUILD,UART_DMA_ENABLE,USE_HAL_DRIVER,STM32F407xx,DISCOVERY_F4_BOARD,ON_DEMAND_PROFILING,ASF_PROFILING,USE_USB_FS
  c misc: -Wno-format -Wno-unused-parameter  -Wno-sign-compare
  c include: ..\Sources\App;..\Sources\Config;..\Sources\BoardSupport;..\..\..\..\Include;..\..\..\Common\App;..\..\..\Common\ASF;..\..\..\..\External\RTOS\CMSIS-RTX\inc;..\..\..\..\External\RTOS\CMSIS-RTX\src;..\..\..\..\External\MCU\STM32F4-CM4\HAL\Inc;..\..\..\..\External\MCU\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\External\Middlewares\ST\STM32_USB_HOST_Library\Core\Inc;..\..\..\..\External\Middlewares\ST\STM32_USB_HOST_Library\Class\MSC\Inc;..\..\..\..\External\Middlewares\FatFs\src;..\..\..\..\External\Middlewares\FatFs\src\drivers;..\..\..\..\external\Middlewares\Helix\pub;..\..\..\..\external\Middlewares\Helix\real;..\..\..\Common\Modules\Bus-Drivers\STM32F4-CM4
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Sources/BoardSupport/: startup_stm32f4xx.s
  group CSLib-HAL
    ../../../../External/MCU/STM32F4-CM4/HAL/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c
    ../../../../external/MCU/STM32F4-CM4/HAL/Src/: stm32f4xx_hal_hcd.c
  group Retarget
    ../Sources/BoardSupport/: Retarget.c
  group ASF
    ../../../Common/ASF/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../Sources/Config/: rtx_conf_cm.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/ARM/: SVC_Table.s
    ../../../../external/RTOS/CMSIS-RTX/SRC/GCC/: HAL_CM4.s
  group App-Common
    ../../../Common/App/: cmdhandler_t.c instrmgr_t.c instrmgr_user.c
  group App
    ../Sources/App/: Console_Util.c Main.c TaskInit_User.c MP3Player_T.c
    ../Sources/Config/: usbh_conf.c
  group BoardSupport
    ../Sources/BoardSupport/: hw_setup.c debugprint.c stm32f4xx_it.c system_stm32f4xx.c cs43l22.c stm32f4_discovery_audio.c stm32f4_discovery.c
  group USBH_Lib/MSC
    ../../../../External/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group USBH_Lib/Core
    ../../../../External/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group FatFs/Core
    ../../../../External/Middlewares/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group FatFs/Driver
    ../../../../External/Middlewares/FatFs/src/drivers/: usbh_diskio.c
  group FatFs/Options
    ../../../../External/Middlewares/FatFs/src/option/: syscall.c unicode.c
  group Helix-MP3-Decoder
    ../../../../external/Middlewares/Helix/: mp3dec.c mp3tabs.c
    ../../../../external/Middlewares/Helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs_fixpt.c
  group Bus-Driver
    ../../../Common/Modules/Bus-Drivers/STM32F4-CM4/: i2c_driver.c
software components: CMSIS:CORE 6.1.0
