<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Discovery-F4-MP3.ewp</path>
    </project>
    <batchBuild />
</workspace>
