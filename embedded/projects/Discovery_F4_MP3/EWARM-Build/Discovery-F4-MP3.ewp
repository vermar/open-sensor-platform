# IAR project Discovery-F4-MP3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FPU_PRESENT=1; __CORTEX_M4F; __CMSIS_RTOS; DEBUG_BUILD; UART_DMA_ENABLE; USE_HAL_DRIVER; STM32F407xx; DISCOVERY_F4_BOARD; ON_DEMAND_PROFILING; ASF_PROFILING; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Sources\App; ..\Sources\BoardSupport; ..\Sources\Config; ..\..\..\common\app; ..\..\..\common\asf; ..\..\..\..\include; ..\..\..\..\external\MCU\STM32F4-CM4\HAL\Inc; ..\..\..\..\external\MCU\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\external\RTOS\CMSIS-RTX\INC; ..\..\..\..\external\MCU\CMSIS\Include; ..\..\..\..\external\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\external\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\external\Middlewares\Helix\pub; ..\..\..\..\external\Middlewares\Helix\real; ..\..\..\..\external\Middlewares\FatFs\src; ..\..\..\..\external\Middlewares\FatFs\src\drivers; ..\..\..\..\external\RTOS\CMSIS-RTX\INC; ..\..\..\..\external\RTOS\CMSIS-RTX\SRC; ..\..\..\common\modules\bus-drivers\STM32F4-CM4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Discovery-F4-MP3.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group App
    ../Sources/App/: Console_Util.c Main.c MP3Player_T.c TaskInit_User.c
    ../Sources/Config/: usbh_conf.c
  group App-Common
    ../../../common/app/: cmdhandler_t.c instrmgr_t.c instrmgr_user.c
  group ASF
    ../../../common/asf/: asf_messages.c asf_taskinit.c asf_timers.c
  group BoardSupport
    ../Sources/BoardSupport/: cs43l22.c debugprint.c hw_setup.c stm32f4_discovery.c stm32f4_discovery_audio.c stm32f4xx_it.c system_stm32f4xx.c
  group Bus-Driver
    ../../../common/modules/bus-drivers/STM32F4-CM4/: i2c_driver.c
  group CSLib-HAL
    ../../../../external/MCU/STM32F4-CM4/HAL/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c
  group FatFs/Core
    ../../../../external/Middlewares/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group FatFs/Driver
    ../../../../external/Middlewares/FatFs/src/drivers/: usbh_diskio.c
  group FatFs/Options
    ../../../../external/Middlewares/FatFs/src/option/: syscall.c unicode.c
  group Helix-MP3-Decoder
    ../../../../external/Middlewares/Helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs_fixpt.c
    ../../../../external/Middlewares/Helix/: mp3dec.c mp3tabs.c
  group Retarget
    ../Sources/BoardSupport/: Retarget.c
  group RTOS
    ../../../../external/RTOS/CMSIS-RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/IAR/: HAL_CM4.s SVC_Table.s
    ../Sources/Config/: rtx_conf_cm.c
  group Startup
    ../Sources/BoardSupport/: startup_stm32f4xx_iar.s
  group USBH_Lib/Core
    ../../../../external/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group USBH_Lib/MSC
    ../../../../external/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
