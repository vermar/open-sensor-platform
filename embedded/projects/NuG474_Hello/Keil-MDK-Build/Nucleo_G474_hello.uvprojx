# Keil uVision project Nucleo_G474_hello.uvprojx, settings and files
target NUCLEO-L474RE (6220000::V6.22::ARMCLANG)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo_G474_hello
  c flags: Optim=6 OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT=1U,__CORTEX_M4F,__CMSIS_RTOS,DEBUG_BUILD,UART_DMA_ENABLE,USE_HAL_DRIVER,STM32G474xx,NUCLEO_G474RE_BOARD,ON_DEMAND_PROFILING,ASF_PROFILING,INCLUDE_TEST_TASK
  c misc: -Wno-unused-parameter -Wno-format -Wno-sign-compare
  c include: ..\Sources\App;..\Sources\Config;..\Sources\BoardSupport;..\..\..\..\include;..\..\..\common\app;..\..\..\common\asf;..\..\..\..\external\MCU\CMSIS\Include;..\..\..\..\external\RTOS\CMSIS-RTX\INC;..\..\..\..\external\RTOS\CMSIS-RTX\SRC;..\..\..\..\external\MCU\STM32G4-CM4\HAL\Inc;..\..\..\..\external\MCU\CMSIS\Device\ST\STM32G4xx\Include
  asm define: __CORTEX_M4F,__CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../Sources/BoardSupport/: startup_stm32g474xx.s
  group CSLib-HAL
    ../../../../external/MCU/STM32G4-CM4/HAL/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Retarget
    ../Sources/BoardSupport/: Retarget.c
  group ASF
    ../../../Common/ASF/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../Sources/Config/: rtx_conf_cm.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/ARM/: SVC_Table.s
    ../../../../external/RTOS/CMSIS-RTX/SRC/GCC/: HAL_CM4.s
  group App-Common
    ../../../Common/App/: cmdhandler_t.c instrmgr_t.c
  group App
    ../Sources/App/: Console_Util.c Main.c TaskInit_User.c InstrMgr_User.c
  group BoardSupport
    ../Sources/BoardSupport/: hw_setup.c debugprint.c stm32g4xx_it.c system_stm32g4xx.c
software components: CMSIS:CORE 6.1.0
