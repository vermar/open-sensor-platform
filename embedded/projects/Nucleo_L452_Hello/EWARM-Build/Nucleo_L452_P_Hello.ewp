# IAR project Nucleo_L452_P_Hello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L452RE ST STM32L452RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FPU_PRESENT=1; __CORTEX_M4F; __CMSIS_RTOS; DEBUG_BUILD; UART_DMA_ENABLE; USE_HAL_DRIVER; STM32L452xx; NUCLEO_L452RE_BOARD; ON_DEMAND_PROFILING; ASF_PROFILING; INCLUDE_TEST_TASK
  ICCARM.CCIncludePath2: ..\Sources\App; ..\Sources\Config; ..\Sources\BoardSupport; ..\..\..\..\include; ..\..\..\common\app; ..\..\..\common\asf; ..\..\..\..\external\MCU\CMSIS\Include; ..\..\..\..\external\RTOS\CMSIS-RTX\INC; ..\..\..\..\external\RTOS\CMSIS-RTX\SRC; ..\..\..\..\external\MCU\STM32L4-CM4\HAL\Inc; ..\..\..\..\external\MCU\CMSIS\Device\ST\STM32L4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Nucleo_L452_P_Hello.srec
  ILINK.IlinkOutputFile: Nucleo_L452_P_Hello.out
  ILINK.IlinkIcfFile: stm32l452xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../Sources/App/: Console_Util.c InstrMgr_User.c Main.c TaskInit_User.c
  group App-Common
    ../../../common/app/: cmdhandler_t.c instrmgr_t.c
  group ASF
    ../../../common/asf/: asf_messages.c asf_taskinit.c asf_timers.c
  group BoardSupport
    ../Sources/BoardSupport/: debugprint.c hw_setup.c stm32l4xx_it.c system_stm32l4xx.c
  group CSLib-HAL
    ../../../../external/MCU/STM32L4-CM4/HAL/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Retarget
    ../Sources/BoardSupport/: Retarget.c
  group RTOS
    ../../../../external/RTOS/CMSIS-RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/IAR/: HAL_CM4.s SVC_Table.s
    ../Sources/Config/: rtx_conf_cm.c
  group Startup
    ../Sources/BoardSupport/: startup_stm32l452xx_iar.s
