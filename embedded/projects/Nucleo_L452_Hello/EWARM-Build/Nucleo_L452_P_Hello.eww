<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Nucleo_L452_P_Hello.ewp</path>
    </project>
    <batchBuild />
</workspace>
