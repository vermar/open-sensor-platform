# Keil uVision project Nucleo_L452_hello.uvprojx, settings and files
target NUCLEO-L452RE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L452RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo_L452RE_Hello
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FPU_PRESENT=1,__CORTEX_M4F,__CMSIS_RTOS,DEBUG_BUILD,UART_DMA_ENABLE,USE_HAL_DRIVER,STM32L452xx,NUCLEO_L452RE_BOARD,ON_DEMAND_PROFILING,ASF_PROFILING,INCLUDE_TEST_TASK
  c include: ..\Sources\App;..\Sources\Config;..\Sources\BoardSupport;..\..\..\..\include;..\..\..\common\app;..\..\..\common\asf;..\..\..\..\external\MCU\CMSIS\Include;..\..\..\..\external\RTOS\CMSIS-RTX\INC;..\..\..\..\external\RTOS\CMSIS-RTX\SRC;..\..\..\..\external\MCU\STM32L4-CM4\HAL\Inc;..\..\..\..\external\MCU\CMSIS\Device\ST\STM32L4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Startup
    ../Sources/BoardSupport/: startup_stm32l452xx.s
  group CSLib-HAL
    ../../../../external/MCU/STM32L4-CM4/HAL/Src/: stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_tim_ex.c
  group Retarget
    ../Sources/BoardSupport/: Retarget.c
  group ASF
    ../../../Common/ASF/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../Sources/Config/: rtx_conf_cm.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/ARM/: HAL_CM4.c SVC_Table.s
  group App-Common
    ../../../Common/App/: cmdhandler_t.c instrmgr_t.c
  group App
    ../Sources/App/: Console_Util.c Main.c TaskInit_User.c InstrMgr_User.c
  group BoardSupport
    ../Sources/BoardSupport/: hw_setup.c debugprint.c stm32l4xx_it.c system_stm32l4xx.c
software components: CMSIS:CORE 5.2.0
