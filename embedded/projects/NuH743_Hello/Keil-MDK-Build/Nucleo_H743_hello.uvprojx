# Keil uVision project Nucleo_H743_hello.uvprojx, settings and files
target NUCLEO-H743ZI (6220000::V6.22::ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Nucleo_H743ZI_hello
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT=1U,__CORTEX_M4F,__CMSIS_RTOS,DEBUG_BUILD,UART_DMA_ENABLE,USE_HAL_DRIVER,STM32H743xx,NUCLEO_H743ZI_BOARD,ON_DEMAND_PROFILING,ASF_PROFILING,n_INCLUDE_TEST_TASK
  c misc: -Wno-unused-parameter -Wno-format -Wno-sign-compare
  c include: ..\Sources\App;..\Sources\Config;..\Sources\BoardSupport;..\..\..\..\include;..\..\..\common\app;..\..\..\common\asf;..\..\..\common\modules\bus-drivers;..\..\..\..\external\MCU\CMSIS\Include;..\..\..\..\external\RTOS\CMSIS-RTX\INC;..\..\..\..\external\RTOS\CMSIS-RTX\SRC;..\..\..\..\external\MCU\STM32H7-CM7\HAL\Inc;..\..\..\..\external\MCU\CMSIS\Device\ST\STM32H7xx\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../Sources/BoardSupport/: startup_stm32h743xx.s
  group CSLib-HAL
    ../../../../external/MCU/STM32H7-CM7/HAL/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c
  group Retarget
    ../Sources/BoardSupport/: Retarget.c
  group ASF
    ../../../Common/ASF/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../Sources/Config/: rtx_conf_cm.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/ARM/: SVC_Table.s
    ../../../../external/RTOS/CMSIS-RTX/SRC/GCC/: HAL_CM4.s
  group App-Common
    ../../../Common/App/: cmdhandler_t.c instrmgr_t.c
  group App
    ../Sources/App/: Console_Util.c Main.c TaskInit_User.c InstrMgr_User.c FactoryTest_T.c
  group BoardSupport
    ../Sources/BoardSupport/: hw_setup.c debugprint.c stm32h7xx_it.c system_stm32h7xx.c
  group Bus-Drivers
    ../../../common/modules/bus-drivers/STM32H7-CM7/: I2C_CmnDriver.c
software components: CMSIS:CORE 6.1.0
