# Keil uVision project NuF413_Hello.uvprojx, settings and files
target STM32F413-Nucleo (6220000::V6.22::ARMCLANG)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NuF413_Hello
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT=1U,__CORTEX_M4F, __CMSIS_RTOS,DEBUG_BUILD,UART_DMA_ENABLE,USE_HAL_DRIVER,STM32F413xx,NUCLEO_F413ZH_BOARD,ON_DEMAND_PROFILING,ASF_PROFILING,USE_USB_FS
  c misc: -Wno-format -Wno-unused-parameter  -Wno-sign-compare
  c include: ..\Sources\App;..\Sources\Config;..\Sources\BoardSupport;..\..\..\..\Include;..\..\..\Common\App;..\..\..\Common\ASF;..\..\..\..\External\RTOS\CMSIS-RTX\inc;..\..\..\..\External\RTOS\CMSIS-RTX\src;..\..\..\..\External\MCU\STM32F4-CM4\HAL\Inc;..\..\..\..\External\MCU\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\External\MCU\CMSIS\Include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Sources/BoardSupport/: startup_stm32f413xx.s
  group CSLib-HAL
    ../../../../External/MCU/STM32F4-CM4/HAL/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Retarget
    ../Sources/BoardSupport/: Retarget.c
  group ASF
    ../../../Common/ASF/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../Sources/Config/: rtx_conf_cm.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/ARM/: SVC_Table.s
    ../../../../external/RTOS/CMSIS-RTX/SRC/GCC/: HAL_CM4.s
  group App-Common
    ../../../Common/App/: cmdhandler_t.c instrmgr_t.c instrmgr_user.c
  group App
    ../Sources/App/: Console_Util.c Main.c TaskInit_User.c
  group BoardSupport
    ../Sources/BoardSupport/: hw_setup.c debugprint.c stm32f4xx_it.c system_stm32f4xx.c
software components: CMSIS:CORE 6.1.0
