# IAR project Nu746_LwIP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: __FPU_PRESENT=1; __CORTEX_M4F; __CMSIS_RTOS; DEBUG_BUILD; UART_DMA_ENABLE; USE_HAL_DRIVER; STM32F746xx; NUCLEO_F746_BOARD; ON_DEMAND_PROFILING; ASF_PROFILING
  ICCARM.CCDiagSuppress: Pe111
  ICCARM.CCIncludePath2: ..\Sources\App; ..\Sources\Config; ..\Sources\BoardSupport; ..\..\..\..\include; ..\..\..\common\app; ..\..\..\common\asf; ..\..\..\..\external\MCU\CMSIS\Include; ..\..\..\..\external\RTOS\CMSIS-RTX\INC; ..\..\..\..\external\RTOS\CMSIS-RTX\SRC; ..\..\..\..\external\MCU\STM32F7-CM7\HAL\Inc; ..\..\..\..\external\MCU\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\external\Middlewares\LwIP\src\include; ..\..\..\..\external\Middlewares\LwIP\src\include\ipv4; ..\..\..\..\external\Middlewares\LwIP\ports\cmsis-rtos\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group App
    ../Sources/App/: app_ethernet.c Console_Util.c fs.c httpserver-netconn.c InstrMgr_User.c Main.c TaskInit_User.c
  group App-Common
    ../../../common/app/: cmdhandler_t.c instrmgr_t.c
  group ASF
    ../../../common/asf/: asf_messages.c asf_taskinit.c asf_timers.c
  group BoardSupport
    ../Sources/BoardSupport/: debugprint.c ethernetif.c hw_setup.c stm32f7xx_it.c system_stm32f7xx.c
  group HAL-Lib
    ../../../../external/MCU/STM32F7-CM7/HAL/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_uart.c
  group LwIP/API
    ../../../../external/Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/Core
    ../../../../external/Middlewares/LwIP/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP/Core/IPv4
    ../../../../external/Middlewares/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/NetIF
    ../../../../external/Middlewares/LwIP/src/netif/: etharp.c
  group LwIP/OS-Port
    ../../../../external/Middlewares/LwIP/ports/cmsis-rtos/: sys_arch.c
  group Retarget
    ../Sources/BoardSupport/: Retarget.c
  group RTOS
    ../../../../external/RTOS/CMSIS-RTX/SRC/: HAL_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
    ../../../../external/RTOS/CMSIS-RTX/SRC/IAR/: HAL_CM4.s SVC_Table.s
    ../Sources/Config/: rtx_conf_cm.c
  group Startup
    ../Sources/BoardSupport/: startup_stm32f746xx_iar.s
