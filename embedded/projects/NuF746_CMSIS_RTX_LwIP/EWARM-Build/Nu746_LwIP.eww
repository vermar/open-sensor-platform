<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Nu746_LwIP.ewp</path>
    </project>
    <batchBuild />
</workspace>
